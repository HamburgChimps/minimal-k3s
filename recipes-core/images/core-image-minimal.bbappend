 IMAGE_INSTALL += " minimal-k3s"